# Keil uVision project Hello.uvproj, settings and files
target LPC2100 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c Serial.c
  group Source Code
    ./: Hello.c
  group Documentation
    ./: Abstract.txt

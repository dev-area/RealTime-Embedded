# IAR project Uart.ewp, settings and files
configuration JLINK_RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2148 Philips LPC2148
  ICCARM.CCIncludePath2: ..\Source
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: Uart.out
  ILINK.IlinkIcfFile: ..\Configuration\LPC2148_RAM.icf
configuration JLINK_FLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\Configuration\LPC2148_Flash.icf
  group (top)
    ../Source/: Demo.c lpc2xxx_cstartup.s
  group Documentation
    ../: readme.txt
